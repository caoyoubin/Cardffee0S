# Keil uVision project cos_smartcard_sosse.uvproj, settings and files
target sosse (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cos_smartcard_sosse
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Include
  asm include: ..\Lib
  group src
    ../SRC/: auth.c authtest.c commands.c ctapi.c fs.c fstest.c fstream.c hal.c hal-emu.c log.c main.c newdes-sk.c skipjack.c sw.c t0.c tea.c tools.c transaction.c
